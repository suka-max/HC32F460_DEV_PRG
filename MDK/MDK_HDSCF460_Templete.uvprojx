# Keil uVision project MDK_HDSCF460_Templete.uvprojx, settings and files
target MDK_HDSCF460_Templete (6190000::V6.19::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.10
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MDK_HDSCF460_Templete +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HC32F460,USE_DDL_DRIVER
  c include: ..\CMSIS\CORE\Include;..\drivers\hc32_ll_driver\inc;..\CMSIS\Device\HDSC\hc32f4xx\Include;..\source\inc;..\coremark;..\drivers\SPI;..\drivers\OLED
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group CMSIS
    ../CMSIS/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c startup_hc32f460.s
  group source
    ../source/: main.c
  group drivers
    ../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_aes.c hc32_ll_can.c hc32_ll_adc.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c ee_printf.c
  group oled
    ../drivers/OLED/: OLED.c
    ../drivers/SPI/: SPI.c
